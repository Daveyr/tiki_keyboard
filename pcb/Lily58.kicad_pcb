# Repository Daveyr/tiki_keyboard

## KiCad design pcb/Lily58.kicad_pcb

Board: 2 copper layers, 142.5 x 106.3 mm, 84 parts (4 on the bottom side), 53 nets.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29: D; Diode_TH_SOD123
J1: LED; StripLED
J2: 4PIN; MJ-4PP-9
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8: Jumper
OLED: OLED; MY_SIL-4
P1, P2: i2c_pin; 1pin_conn
P3: ICSP
R1, R2: R; RESISTOR_mini
RSW1: SW_RST; TACT_SWITCH_TVBP06
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW27, SW28, SW29: SW_PUSH; MX_PG1350-Under_FLIP_HOLES_18mm
SW26: SW_PUSH; MX_PG1350-Under_FLIP_HOLES_27mm
TH1, TH2: HOLE; M2_HOLE_PCB
TH3, TH4, TH5, TH6, TH7: HOLE; HOLE_M2_TH
U1: ProMicro; ProMicro_rev2
W1: jumper; jumper_data

Connections:
DATA: U1.2, W1.1
GND: J1.3, J2.2, JP1.2, JP8.2, P3.6, RSW1.1, U1.3, U1.4, U1.23
LED: J1.2, U1.1
unnamed: D1.2, SW1.2
unnamed: D2.2, SW2.2
unnamed: D3.2, SW3.2
unnamed: D4.2, SW4.2
unnamed: D5.2, SW5.2
unnamed: D6.2, SW6.2
unnamed: D7.2, SW7.2
unnamed: D8.2, SW8.2
unnamed: D9.2, SW9.2
unnamed: D10.2, SW10.2
unnamed: D11.2, SW11.2
unnamed: D12.2, SW12.2
unnamed: D13.2, SW13.2
unnamed: D14.2, SW14.2
unnamed: D15.2, SW15.2
unnamed: D16.2, SW16.2
unnamed: D17.2, SW17.2
unnamed: D18.2, SW18.2
unnamed: D19.2, SW19.2
unnamed: D20.2, SW20.2
unnamed: D21.2, SW21.2
unnamed: D22.2, SW22.2
unnamed: D23.2, SW23.2
unnamed: D24.2, SW24.2
unnamed: D25.2, SW25.2
unnamed: D26.2, SW26.2
unnamed: D27.2, SW27.2
unnamed: D28.2, SW28.2
unnamed: D29.2, SW29.2
unnamed: J2.3, P2.1, W1.2
unnamed: J2.4, P1.1
unnamed: JP1.1, JP5.1, OLED.4
unnamed: JP2.1, JP6.1, OLED.3
unnamed: JP3.1, JP7.1, OLED.2
unnamed: JP4.1, JP8.1, OLED.1
RESET: P3.5, RSW1.2, U1.22
SCL: JP3.2, JP6.2, R2.2, U1.6
SDA: JP4.2, JP5.2, R1.2, U1.5
VCC: J1.1, J2.1, JP2.2, JP7.2, P3.2, R1.1, R2.1, U1.21
col0: SW6.1, SW12.1, SW18.1, SW24.1, U1.18
col1: SW5.1, SW11.1, SW17.1, SW23.1, SW29.1, U1.17
col2: P3.3, SW4.1, SW10.1, SW16.1, SW22.1, SW28.1, U1.16
col3: P3.1, SW3.1, SW9.1, SW15.1, SW21.1, SW27.1, U1.15
col4: P3.4, SW2.1, SW8.1, SW14.1, SW20.1, SW26.1, U1.14
col5: SW1.1, SW7.1, SW13.1, SW19.1, SW25.1, U1.13
row0: D1.1, D2.1, D3.1, D4.1, D5.1, D6.1, U1.8
row1: D7.1, D8.1, D9.1, D10.1, D11.1, D12.1, U1.9
row2: D13.1, D14.1, D15.1, D16.1, D17.1, D18.1, U1.10
row3: D19.1, D20.1, D21.1, D22.1, D23.1, D24.1, U1.11
row4: D25.1, D26.1, D27.1, D28.1, D29.1, U1.12

## Commit log

2020-10-17 generate JLPCB compatible gerbers
2020-10-18 rotary encoder on schematic
2020-12-03 at stage where pcbs where ordered
